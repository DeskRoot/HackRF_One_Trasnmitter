options:
  parameters:
    author: alkin
    generate_options: qt_gui
    id: mic
    output_language: python
    title: Mic Transmitteri
  states: {}

blocks:
- name: frekans
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 200e3
    stop: 6e9
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '88200'
    fh: '-1.0'
    max_dev: 15e3
    quad_rate: '88200'
    tau: '25e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: SteelSeries Arctis 9 Chat
    samp_rate: '48000'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: 999999e9
    freq0: frekans
    gain0: 999999e9
    if_gain0: 999999e9
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '67'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
