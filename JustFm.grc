options:
  parameters:
    author: alkin
    generate_options: qt_gui
    id: JustFm
    output_language: python
    title: Just Fm Transmitter
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 86e6
    step: 200e3
    stop: 109e6
    value: 86e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '88200'
    fh: '-1.0'
    max_dev: 30e3
    quad_rate: '88200'
    tau: '25e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\alkin\Desktop\FM\Music\Heute Nacht.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: '0'
    args: '"hackrf"'
    bb_gain0: 9999999e9
    freq0: frequency
    gain0: 9999999e9
    if_gain0: 9999999e9
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '67'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
