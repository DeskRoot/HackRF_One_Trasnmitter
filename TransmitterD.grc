options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Broadcast Frequency
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: 200e3
    stop: 6e9
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '88200'
    fh: '-1.0'
    max_dev: 25e3
    quad_rate: '88200'
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\alkin\Desktop\FM\Music\XTC - The Chemical Brothers Remix.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf"'
    bb_gain0: 9999999e99
    freq0: frequency
    gain0: 9999999e99
    if_gain0: 9999999e99
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '67'
    type: ccc
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
